# Enforce linkage for openSSL with version 3.0.x
OPENSSL_LINKING_MODE = "-linked"

PR = "r1"
