RDEPENDS:${PN} += " \
  ${PYTHON_PN}-distutils \
  ${PYTHON_PN}-image \
"

PR = "r1"
