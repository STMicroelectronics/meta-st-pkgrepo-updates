# We change the package name...
PN = "python3-jsonschema-4.17.3"

# but we should keep it for pypi so the archive could be retrieved
PYPI_PACKAGE = "jsonschema"
