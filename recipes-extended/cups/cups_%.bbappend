PR = "r1"

# Remove the static service
SYSTEMD_SERVICE_${PN}_remove = "org.cups.cups-lpd@.service"
