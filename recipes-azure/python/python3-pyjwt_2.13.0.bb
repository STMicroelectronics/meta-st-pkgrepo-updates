SUMMARY = "JSON Web Token implementation in Python"
DESCRIPTION = "PyJWT is a Python library which allows you to encode \
and decode JSON Web Tokens (JWT). JWT is an open, industry-standard \
(RFC 7519) for representing claims securely between two parties."
HOMEPAGE = "https://github.com/jpadilla/pyjwt"

inherit pypi python_setuptools_build_meta

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=e4b56d2c9973d8cf54655555be06e551"
SRC_URI[sha256sum] = "41571c89ca91598c79e8ef18a2d07367d4810fbbd6f637794879baf1b7703423"
